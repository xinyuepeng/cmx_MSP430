# IAR project cmx135.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F147 MSP430F147
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: cmxmod
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F147.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: CC430F5133 CC430F5133
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: DynamentPrimer.c DynamentPrimer.h IODefines.h main.c PowerClockControl.c PowerClockControl.h SysConfig.h SysUart.c SysUart.h
  group cmx
    cmxmod/: Cmx_inip.c Cpconfig.h Cpdefine.h Cpextern.h Cpfuncs.h CPSKV1.s43 Cpstruct.h Cpvendor.h Cxpver1.c Tinyp.c Tinypa.s43
